# Keil uVision project USART1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\library\CMSIS\Core\CM3;.\library\STM32F10x_StdPeriph_Driver\inc;.\library\Template
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./USER/: main.c
    ./library/Template/: stm32f10x_it.c
  group GPIO
    ./library/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c
  group RCC
    ./library/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c
  group CMSIS
    ./library/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group MISC&NVIC
    ./library/STM32F10x_StdPeriph_Driver/src/: misc.c
  group USART
    ./library/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c
