# Keil uVision project embedded.uvproj, settings and files
target embeded (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: embedded +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\stc_lib\STM32F10x_StdPeriph_Driver\inc;..\user_code\inc\init;..\stc_lib\CMSIS\Core\CM3;..\user_code\inc\config;..\user_code\inc;..\user_code\inc\app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group boot_code
    ./: startup_stm32f10x_hd.s
  group src
    ../user_code/src/: main.c stm32f10x_it.c
    ../user_code/src/init/: sys_init.c
    ../user_code/src/app/: app.c
  group stc_lib
    ../stc_lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group cmsis
    ../stc_lib/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
